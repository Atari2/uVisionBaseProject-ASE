# Keil uVision project uvision_exam.uvprojx, settings and files
target uvision_exam (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uvision_exam
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./: main.c startup_LPC17xx.s system_LPC17xx.c macros.h source.s misc.c misc.h core_cm3.c
  group adc
    ./adc/: adc.h IRQ_adc.c lib_adc.c
  group glcd
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group joystick
    ./joystick/: funct_joystick.c joystick.h lib_joystick.c
  group rit
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group sound
    ./sound/: libsound.c libsound.h
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group touchpanel
    ./TouchPanel/: TouchPanel.c TouchPanel.h
  group drawing
    ./drawing/: drawing.c drawing.h
  group led
    ./led/: funct_led.c led.h lib_led.c
  group button
    ./button/: button.c button.h irq_button.c
software components: CMSIS:CORE 5.5.0
